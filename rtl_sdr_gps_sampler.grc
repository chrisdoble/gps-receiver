options:
  parameters:
    generate_options: qt_gui
    id: rtl_sdr_gps_sampler
    output_language: python
    title: RTL-SDR GPS sampler
  states: {}

blocks:
- name: timestamp
  id: variable
  parameters:
    value: re.sub(r'[-:+]', '', datetime.now(timezone.utc).isoformat())
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '''./data/samples-'' + timestamp'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime, timezone
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import re
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bias: 'True'
    center_freq: 1575.42e6
    samp_rate: 2.046e6
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
